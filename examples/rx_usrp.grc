options:
  parameters:
    generate_options: qt_gui
    id: rx_usrp
    output_language: python
    title: rx_ursp
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: cr
  id: variable
  parameters:
    value: '4'
  states: {}
- name: crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 470e6
  states: {}
- name: header
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: ldr
  id: variable
  parameters:
    value: 2**sf/bw > 16e-3
  states: {}
- name: payload_len
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sf
  id: variable
  parameters:
    value: '8'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52002'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: lora_decode_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: ldr
    payload_len: payload_len
    spreading_factor: sf
  states: {}
- name: lora_demod_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    fft_factor: '8'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: ldr
    payload_len: payload_len
    peak_search_algorithm: '1'
    peak_search_phase_k: '16'
    spreading_factor: sf
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: bw/2+1e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: firdes.WIN_RECTANGULAR
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: 2*bw/samp_rate
    type: ccf
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: bw
    center_freq0: freq
    dc_offs_enb0: '""'
    dev_addr: addr=192.168.10.4
    dev_args: '""'
    gain0: '1'
    iq_imbal_enb0: '""'
    norm_gain0: 'True'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [lora_decode_0, header, lora_demod_0, header]
- [lora_decode_0, out, blocks_message_debug_0, print_pdu]
- [lora_decode_0, out, blocks_socket_pdu_0, pdus]
- [lora_demod_0, out, blocks_message_debug_0_0, print]
- [lora_demod_0, out, lora_decode_0, in]
- [low_pass_filter_0, '0', pfb_arb_resampler_xxx_0, '0']
- [pfb_arb_resampler_xxx_0, '0', lora_demod_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
